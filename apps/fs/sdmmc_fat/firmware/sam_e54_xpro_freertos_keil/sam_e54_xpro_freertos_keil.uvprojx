# Keil uVision project sam_e54_xpro_freertos_keil.uvprojx, settings and files
target sam_e54_xpro_freertos_keil (6180000::V6.18::ARMCLANG)
  device: ATSAME54P20A Microchip
  pack: Microchip.SAME54_DFP.3.7.122
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sam_e54_xpro_freertos_keil
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\src\config\sam_e54_xpro_freertos_keil;..\src\packs\ATSAME54P20A_DFP;..\src\packs\CMSIS\CMSIS\Core\Include;..\src\packs\CMSIS;.;..\src\config\sam_e54_xpro_freertos_keil\system\fs\fat_fs\file_system;..\src\config\sam_e54_xpro_freertos_keil\system\fs\fat_fs\hardware_access;..\src\third_party\rtos\FreeRTOS\Source\include;..\src\third_party\rtos\FreeRTOS\Source\portable\KEIL\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\src\config\sam_e54_xpro_freertos_keil\sam_e54_xpro_freertos_keil.sct
  group Harmony3
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/nvmctrl/: plib_nvmctrl.h plib_nvmctrl.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/evsys/: plib_evsys.h plib_evsys.c
    ../src/config/sam_e54_xpro_freertos_keil/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_e54_xpro_freertos_keil/driver/sdmmc/src/: drv_sdmmc_local.h drv_sdmmc_file_system.h drv_sdmmc_file_system.c drv_sdmmc.c
    ../src/config/sam_e54_xpro_freertos_keil/: device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h device.h FreeRTOSConfig.h user.h configuration.h sys_tasks.h initialization.c interrupts.c exceptions.c startup_keil.c freertos_hooks.c tasks.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/port/: plib_port.h plib_port.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/clock/: plib_clock.h plib_clock.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/nvic/: plib_nvic.h plib_nvic.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/cmcc/: plib_cmcc.h plib_cmcc.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/tc/: plib_tc_common.h plib_tc0.h plib_tc0.c
    ../src/config/sam_e54_xpro_freertos_keil/peripheral/sdhc/: plib_sdhc_common.h plib_sdhc1.h plib_sdhc1.c
    ../src/config/sam_e54_xpro_freertos_keil/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e54_xpro_freertos_keil/system/time/src/: sys_time_local.h sys_time.c
    ../src/config/sam_e54_xpro_freertos_keil/bsp/: bsp.h bsp.c
    ../src/config/sam_e54_xpro_freertos_keil/system/fs/: sys_fs.h sys_fs_media_manager.h sys_fs_fat_interface.h
    ../src/config/sam_e54_xpro_freertos_keil/system/fs/src/: sys_fs_local.h sys_fs_media_manager_local.h sys_fs.c sys_fs_media_manager.c sys_fs_fat_interface.c
    ../src/config/sam_e54_xpro_freertos_keil/system/fs/fat_fs/file_system/: ff.h ffconf.h ff.c ffunicode.c
    ../src/config/sam_e54_xpro_freertos_keil/system/fs/fat_fs/hardware_access/: diskio.h diskio.c
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/packs/ATSAME54P20A_DFP/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
    ../src/packs/ATSAME54P20A_DFP/: same54p20a.h
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm4.h mpu_armv7.h cachel1_armv7.h
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h deprecated_definitions.h task.h timers.h mpu_prototypes.h mpu_syscall_numbers.h stream_buffer.h message_buffer.h
    ../src/third_party/rtos/FreeRTOS/Source/portable/KEIL/ARM_CM4F/: portmacro.h port.c
    ../src/config/sam_e54_xpro_freertos_keil/driver/: driver.h driver_common.h
    ../src/config/sam_e54_xpro_freertos_keil/system/: system.h system_common.h system_module.h system_media.h
    ../src/config/sam_e54_xpro_freertos_keil/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_e54_xpro_freertos_keil/system/cache/: sys_cache.h sys_cache.c
    ../src/config/sam_e54_xpro_freertos_keil/osal/: osal.h osal_definitions.h osal_freertos.h osal_freertos.c
    ../src/: app.h main.c app.c
    ../src/config/sam_e54_xpro_freertos_keil/system/debug/: sys_debug.h
    ../src/config/sam_e54_xpro_freertos_keil/stdio/: keil_monitor.c
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c list.c queue.c FreeRTOS_tasks.c timers.c event_groups.c stream_buffer.c
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../src/config/sam_e54_xpro_freertos_keil/system/int/src/: sys_int.c
